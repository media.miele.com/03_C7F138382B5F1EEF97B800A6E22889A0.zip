Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: d5c8f3c5-16a4-4419-bb80-1e43156b2f25, NumberOfSaves: 1]
File name: 0001
Time: 2024-08-14T07:23:36+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11159280_CN_DG2840C_EDST-CLST:23284040_CN_11159280_DG2840C_EDST-CLST, (2)
In: Default
Type - Material: z_Miele_Design_Zinc_Steel, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, <Unnamed>, z_Miele_Design_CLST
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 595 mm; Height: 455 mm; Depth: 569 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 23284040_CN_11159280_DG2840C_EDST-CLST; sets with these values: 2

# IfcDistributionPort, Port_353708_1
Description: Flow; FlowDirection: SOURCEANDSINK
